<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\library\library.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\component1\component1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\component2\component2.ewp</path>
    </project>
    <batchBuild />
</workspace>
